Commit message: d

File: rsc/xarm6/xarm6_allegro_wrist_mounted_rotate_prev2.urdf (robot description, URDF)
Before this commit: robot xarm6, 29 links, 28 joints
Joints:
- joint gripper_base_joint: origin xyz=0 0 0.186 rpy=0 0 -1.57 -> xyz=0 0 0.186 rpy=0 -1.57 -1.57

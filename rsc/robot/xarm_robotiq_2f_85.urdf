Commit message: Update gripper urdf

File: rsc/robot/xarm_robotiq_2f_85.urdf (robot description, URDF)
Before this commit: robot xarm_robotiq_2f_85, 17 links, 16 joints
Joints:
- joint robotiq_85_base_joint: origin xyz=0 0 0 rpy=0 0 0 -> xyz=0 0 0.014 rpy=0 0 0
